# Keil uVision project project.uvprojx, settings and files
target project (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(24000000) ESEL ELITTLE
  output: project +hex
  group platform
    ./system/: startup_cm4.S system_cm4.c printf-stdarg.c
  group driver
    ./peripheral/src/: tremo_adc.c tremo_bstimer.c tremo_crc.c tremo_dac.c tremo_delay.c tremo_dma.c tremo_flash.c tremo_gpio.c tremo_i2c.c tremo_i2s.c tremo_iwdg.c tremo_lcd.c tremo_lptimer.c tremo_lpuart.c tremo_pwr.c tremo_rcc.c tremo_spi.c tremo_system.c tremo_timer.c tremo_uart.c tremo_wdg.c
  group app
    ./src/: main.c tremo_it.c Lora_Demo.c bsp_src.c
    ./src/user/: APP.c APP.h
  group Lora
    ./driver/: sx1262-board.c utilities.c
    ./system/: delay.c timer.c
    ./radio/sx126x/: sx126x.c radio.c
  group lora_profile
    ./src/user/: lora_at_cmd.c lora_at_cmd.h lora_cmd_s.c lora_core.c lora_core.h lora_flash.c lora_flash.h lora_function.c lora_user.c lora_user.h ymodem.h ymodem.c send_packet.c lora_cmd_m.c
  group ES8311
    ./src/es8311/: es8311.c
  group tinyMP3
    ./src/tinyMP3/: shine_mp3.c tinymp3.c int2idx.c minimp3.h MP3_data.c
    ./: data_in.c
